COMPATIBLE_MACHINE:eagle = "eagle"
COMPATIBLE_MACHINE:v3msk = "v3msk"
COMPATIBLE_MACHINE:condor = "condor"
COMPATIBLE_MACHINE:v3mzf = "v3mzf"
COMPATIBLE_MACHINE:v3hsk = "v3hsk"
