do_install_prepend() {
    mkdir -p ${D}/${nonarch_base_libdir}
}
